# Keil uVision project template.uvprojx, settings and files
target px4-fmuv5-default (6190000::V6.19::ARMCLANG)
  device: STM32F765IIKx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.14.0
  cpu: IRAM(0x20020000,0x60000) IRAM2(0x20000000,0x20000) IROM(0x08000000,0x200000) IROM2(0x00200000,0x200000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: px4-fmuv5-default +hex
  AfterMake: fromelf --bin !L --output build/px4-fmuv5-default.bin
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=5 v6LangP=6 wLevel=3
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x80000
  scatter file: .\board\linker_scripts\link.sct
