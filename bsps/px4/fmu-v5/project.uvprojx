# Keil uVision project project.uvprojx, settings and files
target px4-fmuv5-default (6190000::V6.19::ARMCLANG)
  device: STM32F765IIKx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.14.0
  cpu: IRAM(0x20020000,0x60000) IRAM2(0x20000000,0x20000) IROM(0x08000000,0x200000) IROM2(0x00200000,0x200000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: px4-fmuv5-default +hex
  AfterMake: fromelf --bin !L --output build/px4-fmuv5-default.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=8 wLevel=3
  c define: __RTTHREAD__, __CLK_TCK=RT_TICK_PER_SECOND, RT_USING_LIBC, __STDC_LIMIT_MACROS, RT_USING_ARMLIBC, STM32F765xx, USE_HAL_DRIVER
  c include: ..\..\..\rtos\rt-thread\components\libc\posix\pthreads;..\..\..\pkgs\queue;..\..\..\rtos\platform\stm32\STM32F7xx_HAL\STM32F7xx_HAL_Driver\Inc;..\..\..\rtos\rt-thread\components\libc\posix\delay;..\..\..\rtos\rt-thread\components\libc\compilers\common\include;..\..\..\pkgs\include;..\..\..\apps\libraries\peripheral\battery;..\..\..\pkgs\version;..\..\..\pkgs;..\..\..\rtos\rt-thread\components\drivers\include;..\..\..\apps\libraries\peripheral\sensor;..\..\..\rtos\rt-thread\components\libc\compilers\common\extension\fcntl\octal;..\..\..\rtos\rt-thread\components\drivers\include;..\..\..\pkgs\perf;..\..\..\pkgs\atomic;..\..\..\apps\utest\test_uorb;..\..\..\pkgs\uORB;..\..\..\pkgs\param\wrapper;..\..\..\pkgs\containers;..\..\..\apps\libraries\peripheral\payload;..\..\..\rtos\platform\stm32\HAL_Drivers;board;..\..\..\rtos\rt-thread\components\drivers\include;..\..\..\pkgs\events;..\..\..\pkgs\libcrc;..\..\..\pkgs\console_buffer;..\..\..\pkgs\param\storage;..\..\..\rtos\rt-thread\components\libc\posix\io\epoll;..\..\..\pkgs\mathlib;..\..\..\apps\libraries\controller;..\..\..\pkgs\hrtimer\V3;..\..\..\rtos\rt-thread\components\utilities\ulog;..\..\..\rtos\platform\stm32\HAL_Drivers\config;..\..\..\pkgs\ringbuffer;..\..\..\rtos\rt-thread\components\drivers\include;..\..\..\rtos\rt-thread\components\finsh;..\..\..\rtos\rt-thread\components\drivers\include;..\..\..\apps\libraries\peripheral\rcinput;..\..\..\rtos\rt-thread\components\libc\posix\ipc;..\..\..\rtos\platform\stm32\STM32F7xx_HAL\CMSIS\Device\ST\STM32F7xx\Include;..\..\..\rtos\rt-thread\components\libc\cplusplus;..\..\..\apps\libraries\peripheral;..\..\..\rtos\rt-thread\include;..\..\..\pkgs\param\interface;..\..\..\pkgs\workq;..\..\..\rtos\rt-thread\components\legacy\dfs;..\..\..\pkgs\module;..\..\..\apps;..\..\..\rtos\rt-thread\components\libc\posix\io\poll;ports;..\..\..\apps\estimator;..\..\..\pkgs\mathlib\math\filter;..\..\..\rtos\platform\stm32\HAL_Drivers\CMSIS\Include;..\..\..\apps\libraries\estimator;..\..\..\rtos\rt-thread\components\drivers\ktime\inc;board\cubemx\Core\Inc;..\..\..\apps\utest;..\..\..\rtos\rt-thread\libcpu\arm\cortex-m7;..\..\..\rtos\rt-thread\components\libc\compilers\common\extension;..\..\..\rtos\rt-thread\libcpu\arm\common;applications;..\..\..\apps\libraries\peripheral\notification;..\..\..\pkgs\matrix;..\..\..\apps\libraries\telemetry;..\..\..\rtos\rt-thread\components\libc\posix\io\eventfd;..\..\..\rtos\rt-thread\components\dfs\dfs_v1\filesystems\devfs;..\..\..\rtos\rt-thread\components\dfs\dfs_v1\filesystems\elmfat;..\..\..\rtos\rt-thread\components\drivers\ktime;.;..\..\..\apps\utest\test_thread;..\..\..\apps\storage;..\..\..\pkgs\vconsole;..\..\..\rtos\rt-thread\components\drivers\spi;..\..\..\pkgs\ulog;..\..\..\rtos\rt-thread\components\utilities\ulog\backend;..\..\..\rtos\rt-thread\components\dfs\dfs_v1\include;..\..\..\rtos\rt-thread\components\drivers\include;..\..\..\pkgs\param;..\..\..\rtos\rt-thread\components\legacy;..\..\..\rtos\rt-thread\components\drivers\include;..\..\..\apps\controller
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x80000
  scatter file: .\board\linker_scripts\link.sct
  group bsp/apps
    applications/: main.c
  group bsp/board
    board/cubemx/Core/Src/: stm32f7xx_hal_msp.c main.c
    board/: board.c
  group bsp/ports
    ports/: sd_mnt.c gpio_init.c
  group Compiler
    ../../../rtos/rt-thread/components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../rtos/rt-thread/components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group CPP
    ../../../rtos/rt-thread/components/libc/cplusplus/: cxx_crt_init.c cxx_crt.cpp
  group CPU
    ../../../rtos/rt-thread/libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../rtos/rt-thread/libcpu/arm/cortex-m7/: context_rvds.S cpu_cache.c cpuport.c
  group DeviceDrivers
    ../../../rtos/rt-thread/components/drivers/core/: device.c
    ../../../rtos/rt-thread/components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../rtos/rt-thread/components/drivers/misc/: adc.c pin.c rt_drv_pwm.c
    ../../../rtos/rt-thread/components/drivers/rtc/: rtc.c
    ../../../rtos/rt-thread/components/drivers/sdio/: block_dev.c gpt.c mmc.c mmcsd_core.c sd.c sdio.c
    ../../../rtos/rt-thread/components/drivers/serial/: serial.c
    ../../../rtos/rt-thread/components/drivers/spi/: spi_core.c spi_dev.c
  group Filesystem
    ../../../rtos/rt-thread/components/dfs/dfs_v1/filesystems/devfs/: devfs.c
    ../../../rtos/rt-thread/components/dfs/dfs_v1/filesystems/elmfat/: dfs_elm.c ff.c ffunicode.c
    ../../../rtos/rt-thread/components/dfs/dfs_v1/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
  group Finsh
    ../../../rtos/rt-thread/components/finsh/: cmd.c msh.c shell.c msh_parse.c msh_file.c
  group hal/stm32f7
    ../../../rtos/platform/stm32/STM32F7xx_HAL/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_spi_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_crc_ex.c stm32f7xx_hal_tim.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_sram.c stm32f7xx_hal_exti.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_sd.c stm32f7xx_hal_usart.c stm32f7xx_hal_rcc.c stm32f7xx_hal_spi.c stm32f7xx_hal_qspi.c stm32f7xx_hal_cortex.c stm32f7xx_hal_cec.c stm32f7xx_hal_rtc_ex.c stm32f7xx_hal_rtc.c stm32f7xx_hal_cryp_ex.c stm32f7xx_hal_lptim.c stm32f7xx_ll_sdmmc.c stm32f7xx_hal_crc.c stm32f7xx_hal_adc.c stm32f7xx_hal_cryp.c stm32f7xx_hal_gpio.c stm32f7xx_hal_pwr.c stm32f7xx_hal_uart_ex.c stm32f7xx_hal_adc_ex.c stm32f7xx_hal_rng.c stm32f7xx_hal.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_dma.c
    ../../../rtos/platform/stm32/STM32F7xx_HAL/CMSIS/Device/ST/STM32F7xx/Source/Templates/arm/: startup_stm32f765xx.s
    ../../../rtos/platform/stm32/STM32F7xx_HAL/CMSIS/Device/ST/STM32F7xx/Source/Templates/: system_stm32f7xx.c
  group Kernel
    ../../../rtos/rt-thread/src/: clock.c components.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_up.c thread.c timer.c
  group ktime
    ../../../rtos/rt-thread/components/drivers/ktime/src/: cputimer.c boottime.c hrtimer.c
  group Legacy
    ../../../rtos/rt-thread/components/legacy/ipc/: workqueue_legacy.c
  group lib/common
    ../../../pkgs/hrtimer/V3/: callout_using_ostimer.c timestamp_using_systick.c hrtimer.c
  group lib/console_buffer
    ../../../pkgs/console_buffer/: console_buffer.cpp
  group lib/ring_buffer
    ../../../pkgs/ringbuffer/: Ringbuffer.cpp
  group pkg/common
    ../../../pkgs/queue/: dq_addafter.c sq_rem.c sq_remlast.c dq_addfirst.c sq_addlast.c dq_count.c dq_remfirst.c dq_remlast.c dq_rem.c sq_addfirst.c sq_addafter.c sq_remafter.c dq_addlast.c sq_cat.c sq_remfirst.c dq_addbefore.c sq_count.c dq_cat.c
  group pkg/events
    ../../../pkgs/events/: events.cpp
  group pkg/getopt
    ../../../pkgs/getopt/: getopt.c
  group pkg/libcrc
    ../../../pkgs/libcrc/: lib_crc8ccitt.c lib_crc8.c lib_crc16.c lib_crc32.c lib_crc64.c
  group pkg/param
    ../../../pkgs/param/: param_interface.c param_storage.c param.c
    ../../../pkgs/param/interface/: param_global_autogen.cpp
    ../../../pkgs/param/storage/: param_storage_file.c
  group pkg/perf
    ../../../pkgs/perf/: perf_counter.cpp
  group pkg/uorb
    ../../../pkgs/uORB/topics/: power_button_state.cpp power_monitor.cpp sensor_accel_fifo.cpp cpuload.cpp ulog_stream.cpp landing_target_innovations.cpp orb_test_large.cpp actuator_armed.cpp vehicle_imu.cpp estimator_status.cpp vehicle_constraints.cpp gimbal_manager_set_manual_control.cpp pps_capture.cpp control_allocator_status.cpp estimator_sensor_bias.cpp vehicle_angular_velocity.cpp heater_status.cpp mavlink_tunnel.cpp action_request.cpp collision_constraints.cpp timesync_status.cpp differential_pressure.cpp log_message.cpp px4io_status.cpp navigator_mission_item.cpp sensor_baro.cpp debug_array.cpp vehicle_command.cpp failsafe_flags.cpp uavcan_parameter_value.cpp obstacle_distance.cpp autotune_attitude_control_status.cpp sensor_gyro_fft.cpp estimator_status_flags.cpp position_controller_landing_status.cpp qshell_req.cpp airspeed.cpp sensor_combined.cpp debug_value.cpp vehicle_global_position.cpp landing_target_pose.cpp gripper.cpp offboard_control_mode.cpp mode_completed.cpp camera_capture.cpp sensor_gyro_fifo.cpp sensor_correction.cpp estimator_aid_source1d.cpp ulog_stream_ack.cpp estimator_bias3d.cpp vehicle_attitude.cpp magnetometer_bias_estimate.cpp yaw_estimator_status.cpp hover_thrust_estimate.cpp npfg_status.cpp cellular_status.cpp takeoff_status.cpp sensor_gyro.cpp trajectory_setpoint.cpp landing_gear_wheel.cpp gimbal_device_attitude_status.cpp collision_report.cpp sensor_mag.cpp sensor_preflight_mag.cpp follow_target.cpp vehicle_odometry.cpp landing_gear.cpp position_controller_status.cpp qshell_retval.cpp rc_channels.cpp airspeed_validated.cpp estimator_states.cpp vehicle_land_detected.cpp uavcan_parameter_request.cpp home_position.cpp orb_test.cpp rc_parameter_map.cpp sensor_hygrometer.cpp trajectory_bezier.cpp vehicle_control_mode.cpp follow_target_status.cpp vehicle_optical_flow.cpp gimbal_manager_status.cpp vtol_vehicle_status.cpp mavlink_log.cpp ekf2_timestamps.cpp estimator_aid_source2d.cpp tune_control.cpp gimbal_manager_information.cpp input_rc.cpp mission.cpp estimator_bias.cpp gimbal_manager_set_attitude.cpp vehicle_trajectory_bezier.cpp adc_report.cpp estimator_aid_source3d.cpp vehicle_imu_status.cpp gps_dump.cpp internal_combustion_engine_status.cpp orb_test_medium.cpp position_setpoint.cpp estimator_gps_status.cpp generator_status.cpp vehicle_optical_flow_vel.cpp vehicle_status.cpp vehicle_trajectory_waypoint.cpp orbit_status.cpp airspeed_wind.cpp sensor_uwb.cpp event.cpp vehicle_magnetometer.cpp iridiumsbd_status.cpp vehicle_thrust_setpoint.cpp position_setpoint_triplet.cpp sensor_optical_flow.cpp radio_status.cpp distance_sensor.cpp gimbal_device_set_attitude.cpp gimbal_device_information.cpp wind.cpp mission_result.cpp actuator_servos.cpp rpm.cpp battery_status.cpp system_power.cpp vehicle_air_data.cpp debug_key_value.cpp vehicle_angular_acceleration_setpoint.cpp led_control.cpp normalized_unsigned_setpoint.cpp actuator_test.cpp task_stack_info.cpp vehicle_attitude_setpoint.cpp esc_status.cpp vehicle_command_ack.cpp vehicle_rates_setpoint.cpp health_report.cpp manual_control_setpoint.cpp actuator_servos_trim.cpp rtl_time_estimate.cpp button_event.cpp vehicle_acceleration.cpp parameter_update.cpp sensor_selection.cpp rate_ctrl_status.cpp transponder_report.cpp gimbal_controls.cpp onboard_computer_status.cpp actuator_motors.cpp tecs_status.cpp sensors_status_imu.cpp esc_report.cpp vehicle_local_position.cpp estimator_event_flags.cpp vehicle_local_position_setpoint.cpp mount_orientation.cpp satellite_info.cpp estimator_innovations.cpp trajectory_waypoint.cpp geofence_result.cpp vehicle_roi.cpp pwm_input.cpp sensors_status.cpp sensor_accel.cpp camera_status.cpp telemetry_status.cpp debug_vect.cpp estimator_selector_status.cpp logger_status.cpp irlock_report.cpp vehicle_torque_setpoint.cpp ping.cpp manual_control_switches.cpp actuator_outputs.cpp tiltrotor_extra_controls.cpp uORBTopics.cpp failure_detector_status.cpp gps_inject_data.cpp mag_worker_data.cpp sensor_gnss_relative.cpp actuator_controls_status.cpp sensor_gps.cpp camera_trigger.cpp follow_target_estimator.cpp launch_detection_status.cpp
    ../../../pkgs/uORB/: Publication.cpp uORB.cpp uORBManager.cpp Subscription.cpp DeviceNode.cpp
  group pkg/vconsole
    ../../../pkgs/vconsole/: vconsole.c
  group pkg/version
    ../../../pkgs/variable_length_ringbuffer/: VariableLengthRingbuffer.cpp
    ../../../pkgs/version/: board_fw_version.c board_hw_version.c board_mcu_version.c board_version_main.c
  group pkg/workq
    ../../../pkgs/workq/: WorkQueue.cpp WorkItemScheduled.cpp WorkItemSingleShot.cpp WorkQueueManager.cpp WorkItem.cpp
  group POSIX
    ../../../rtos/rt-thread/components/libc/posix/delay/: delay.c
    ../../../rtos/rt-thread/components/libc/posix/pthreads/: pthread.c pthread_attr.c pthread_barrier.c pthread_cond.c pthread_mutex.c pthread_rwlock.c pthread_spin.c pthread_tls.c sched.c
  group rtt/Drivers
    ../../../rtos/platform/stm32/HAL_Drivers/: drv_usart.c drv_common.c drv_gpio.c drv_spi.c drv_adc.c
  group utest
    ../../../apps/utest/test_thread/: test_thread.cpp
    ../../../apps/utest/test_uorb/: test_uorb_main.cpp
  group Utilities
    ../../../rtos/rt-thread/components/utilities/ulog/: ulog.c
    ../../../rtos/rt-thread/components/utilities/ulog/backend/: console_be.c file_be.c
